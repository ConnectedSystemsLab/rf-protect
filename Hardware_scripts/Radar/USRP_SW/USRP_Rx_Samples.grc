options:
  parameters:
    generate_options: qt_gui
    id: USRP_Rx_Samples
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: usrp_channel0.dat
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: usrp_channel1.dat
    type: complex
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: A
    ant1: A
    center_freq0: '0'
    center_freq1: '0'
    dev_addr: '"addr=192.168.10.3"'
    gain0: '1'
    gain1: '1'
    nchan: '2'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    stream_chans: '[0,1]'
    sync: none
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_1, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_1, '1', blocks_file_sink_0_0, '0']

metadata:
  file_format: 1
